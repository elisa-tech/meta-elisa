FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# 0001-test-demo.patch to 0001-Recreated-the-patch-from-meta-elisa
SRC_URI += " file://0001-Recreated-the-patch-from-meta-elisa.patch "
