
RDEPENDS_${PN} += "pipe-demo"
